# Keil uVision project uartDMASendReceive.uvprojx, settings and files
target CMS32L051 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: CMS32L051LQ48 Cmsemicon
  pack: Cmsemicon.CMS32L051.1.3.0
  cpu: IRAM(0x20000000,0x02000) IROM(0x00000000,0x10000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: uartDMASendReceive +hex
  c flags: Optim=2 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=5 wLevel=2
  c include: ..\..\..\Driver\inc
  memory RVCT4: ROM 0x0 size 0x10000
  memory RVCT9: RAM 0x200001a0 size 0x1e60
  group Source
    ../: main.c
  group Driver
    ../../../Driver/src/: sci.c sci_user.c dma.c retarget.c
software components: CMSIS:CORE 5.6.0, Device:Startup 1.0.0
