# Keil uVision project adcHardTriggerNoWait.uvprojx, settings and files
target CMS32L051 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: CMS32L051LQ48 Cmsemicon
  pack: Cmsemicon.CMS32L051.1.0.0
  cpu: IRAM(0x20000000,0x02000) IROM(0x00000000,0x10000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: adcHardTriggerNoWait +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: ..\..\..\Driver\inc
  memory RVCT4: ROM 0x0 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  scatter file: .\scatter.map
  group Source
    ../: main.c
  group Driver
    ../../../Driver/src/: adc.c adc_user.c rtc.c rtc_user.c dma.c sci.c sci_user.c retarget.c
software components: CMSIS:CORE 5.4.0, Device:Startup 1.0.0
